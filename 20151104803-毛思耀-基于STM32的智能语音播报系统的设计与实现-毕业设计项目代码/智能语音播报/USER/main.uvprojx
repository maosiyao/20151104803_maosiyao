# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MyCode\led;..\MyCode\LCD1602;..\MyCode\temper;..\MyCode\AT24C02;..\MyCode\TIMER;..\MyCode\KEY4;..\MyCode\dht11;..\MyCode\sim900a;..\MyCode\RTC;..\MyCode\esp8266;..\MyCode\12864;..\MyCode\xfs5152
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group MyCode
    ../MyCode/led/: LED.c
    ../MyCode/temper/: tsensor.c
    ../MyCode/TIMER/: timer.c
    ../MyCode/KEY4/: key4.c
    ../MyCode/dht11/: dht11.c
    ../MyCode/12864/: 12864.c
    ../MyCode/xfs5152/: xfs5152.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32_FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
